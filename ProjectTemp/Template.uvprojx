# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\SysTick;.\APP\PWM;.\APP\RS485;.\APP\printf;.\APP\IIC(24C02);.\APP\AT24Cxx;.\APP\DS18B20;.\APP\ADC;.\APP\beep;.\APP\exit;.\APP\key;.\APP\smg;.\APP\time;.\APP\usart;.\APP\dac;.\APP\SPI;.\APP\sys;.\APP\LCD;.\APP\touch;.\APP\GPIO_State;.\APP\W5500;.\APP\1479A;.\APP\DataProcess;.\APP\VacuumGauge;.\APP\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_dma.c
  group APP
    ./APP/LED/: led.c
    ./APP/SysTick/: systick.c
    ./APP/PWM/: pwm.c
    ./APP/RS485/: rs485.c
    ./APP/printf/: printf.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/AT24Cxx/: AT24CXX.c
    ./APP/DS18B20/: ds18b20.c
    ./APP/beep/: beep.c
    ./APP/exit/: exti.c
    ./APP/key/: key.c
    ./APP/smg/: smg.c
    ./APP/time/: time.c
    ./APP/usart/: usart.c
    ./APP/dac/: dac.c
    ./APP/ADC/: adc.c
    ./APP/LCD/: gui.c lcd.c test.c
    ./APP/SPI/: spi.c
    ./APP/GPIO_State/: IOState.c
    ./APP/W5500/: w5500.c
    ./APP/DataProcess/: DataProcess.c
    ./APP/VacuumGauge/: VacuumG.c
    ./APP/1479A/: 1479A.c
    ./APP/IWDG/: iwdg.c
